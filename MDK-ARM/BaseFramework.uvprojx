# Keil uVision project BaseFramework.uvprojx, settings and files
target BaseFramework (6220000::V6.22::ARMCLANG)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: BaseFramework +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: APPLICATION_ADDRESS=0x90000000U,USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H750xx,LFS_DEFINES=lfs_armclang_port.h
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Middlewares/ST/ARM/DSP/Inc;../Core/Inc/SEGGER;../src;../src/service/sfud/inc;../src/service/lfs;../src/bsp/spi_flash;../src/bsp/rtt;../src/bsp/uart;../src/bsp/tft_port;../src/service/gfx;../src/service/gfx/Fonts;../src/driver/st7735;../src/service/cli;../src/service/cli/log;../src/service/cli/port;../src/service/sys;../src/common/tools;../src/service/gui;../src/service/gui/MujicaUI_Lite
  asm include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Middlewares/ST/ARM/DSP/Inc;../Core/Inc/SEGGER
  memory RVCT4: ROM 0x90000000 size 0x800000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\BaseFramework.sct
  group Application/MDK-ARM
    ./: startup_stm32h750xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c dac.c dma.c opamp.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_opamp.c stm32h7xx_hal_opamp_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Application/User/SEGGER
    ../Core/Src/SEGGER/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_SYSVIEW.c SEGGER_SYSVIEW_FreeRTOS.c SEGGER_SYSVIEW_Config_STM32H750.c
  group Application/User/BSP
    ../src/bsp/spi_flash/: spi_flash.c
    ../src/bsp/rtt/: rtt.c
    ../src/bsp/uart/: uart_async.c
    ../src/bsp/dac/: bsp_dac.c bsp_dac.h
    ../src/bsp/adc/: bsp_adc.c bsp_adc.h
    ../src/bsp/fan/: bsp_fan.c bsp_fan.h
    ../src/bsp/gpio/: bsp_gpio.c bsp_gpio.h
  group Application/User/LoadOut
    ../src/service/load/: load_out.c load_out.h
    ../src/service/sense/: sense.c sense.h
    ../src/service/fan/: fan.c fan.h
  group Application/User/SFUD
    ../src/service/sfud/src/: sfud.c sfud_sfdp.c
    ../src/service/sfud/port/: sfud_port.c
    ../src/bsp/tim/: bsp_timer.c bsp_timer.h
  group Application/User/LFS
    ../src/service/lfs/: lfs.c lfs_util.c lfs_port.c
  group Application/User/TFT_Port
    ../src/bsp/tft_port/: Arduino.cpp Print.cpp SpiWrapper.cpp tft_fb.cpp
  group Application/User/GFX
    ../src/service/gfx/: Adafruit_GFX.cpp Adafruit_SPITFT.cpp
  group Application/User/ST7735
    ../src/driver/st7735/: Adafruit_ST77xx.cpp Adafruit_ST7735.cpp
  group Application/User/App
    ../src/app/: loader_cli.c loader_config.h loader_core.c loader_core.h loader_runtime.c loader_runtime.h loader_task.c loader_task.h loader_ui.c
  group Application/User/MujicaUI
    ../src/service/gui/MujicaUI_Lite/: mjc_hal.c mjc_hal_gfx.cpp mjc_core.c mjc_render.c
    ../src/service/gui/: multi_button.c
  group Application/User/CLI
    ../src/service/cli/: shell.c shell_cmd_list.c shell_companion.c shell_ext.c cpu_cmd.c
    ../src/service/cli/log/: log.c
    ../src/service/cli/port/: shell_port.c
  group Application/User/SYS
    ../src/service/sys/: sys_log.c sys_time.c
  group Application/User/Common
    ../src/common/tools/: common_def.c
    ../src/common/pid/: pid.c pid.h
software components: CMSIS:CORE 6.2.0
